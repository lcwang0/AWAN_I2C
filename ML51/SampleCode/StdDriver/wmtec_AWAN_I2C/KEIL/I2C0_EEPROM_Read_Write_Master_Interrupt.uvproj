# Keil uVision project I2C0_EEPROM_Read_Write_Master_Interrupt.uvproj, settings and files
target I2C0_EEPROM_Read_Write_Master_Interrupt (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: I2C0_EEPROM_Read_Write_Master_Interrupt +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c i2c.c gpio.c delay.c pinint.c timer.c wdt.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
