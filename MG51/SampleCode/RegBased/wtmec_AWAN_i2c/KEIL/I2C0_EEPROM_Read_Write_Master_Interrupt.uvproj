# Keil uVision project I2C0_EEPROM_Read_Write_Master_Interrupt.uvproj, settings and files
target I2C0_EEPROM_Read_Write_Master_Interrupt (MCS-51)
  device: MG51FC9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: AWAN_I2C +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c i2c.c delay.c timer.c wdt.c sys.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
